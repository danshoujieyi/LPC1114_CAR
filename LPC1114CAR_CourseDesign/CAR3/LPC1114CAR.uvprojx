# Keil uVision project LPC1114CAR.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: LPC1114FBD48/302 NXP
  pack: Keil.LPC1100_DFP.1.4.1
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LPC1114CAR
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\USER;.\Drivers;.\Drivers_Config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source Group 1
    ./: main.c
  group Drivers
    ./Drivers/: adc.c adc.h can.c can.h clkconfig.c clkconfig.h crp.c crp.h debug_printf.c debug_printf.h gpio.c gpio.h i2c.c i2c.h i2cslave.c i2cslave.h lpc_swu.c lpc_swu.h rom_driver_CAN.h rom_drivers.h rs485.c rs485.h small_gpio.c small_gpio.h ssp.c ssp.h timer16.c timer16.h timer32.c timer32.h type.h uart.c uart.h wdt.c wdt.h
  group USER
    ./USER/: Delay.c Delay.h LED.c LED.h Motor.c Motor.h NRF24L01.c NRF24L01.h NRF24L01REG.h OLED.c OLED.h OLED_Font.h Track.c Track.h Ultrasonic.c Ultrasonic.h PID.c PID.h Key.c Key.h
  group Drivers_Config
    ./Drivers_Config/: driver_config.h system_LPC11xx.h target_config.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0, RTOS:kernel 3.1.5
